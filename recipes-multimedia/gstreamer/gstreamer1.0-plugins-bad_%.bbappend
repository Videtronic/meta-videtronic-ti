PACKAGECONFIG:append = " kms"